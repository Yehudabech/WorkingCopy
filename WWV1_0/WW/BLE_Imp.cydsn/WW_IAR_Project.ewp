# IAR project WW_IAR_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYBLE-224110-00 Cypress CYBLE-224110-00
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CY_CORE_ID=0
  ICCARM.IExtraOptions: -DCyTemp
  ICCARM.CCIncludePath2: .; Generated_Source\PSoC4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; CY_CORE_ID=0
  AARM.AUserIncludes: .; Generated_Source\PSoC4
  postbuild: ".\Export\postbuild.bat" "$TARGET_PATH$" "$PROJ_DIR$" "$TARGET_DIR$" "$TOOLKIT_DIR$" "" "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: WW_IAR_Project.out
  ILINK.IlinkIcfFile: .\Generated_Source\PSoC4\Cm0Iar.icf
  ILINK.IlinkExtraOptions: .\Export\ARM_IAR_Generic\BLE_v3_52\gccCyBLEStack_BLE_SOC_PERIPHERAL.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCOptLevel: 3
  group (top)
    Export/: BLE_Imp.ipcf
  group BLE_Imp/Generated_Header
    Generated_Source/PSoC4/: BLE.h BLE_bless_isr.h BLE_custom.h BLE_eventHandler.h BLE_gatt.h BLE_HAL_PVT.h BLE_Stack.h BLE_STACK_PVT.h BLE_StackGap.h BLE_StackGatt.h BLE_StackGattClient.h BLE_StackGattDb.h BLE_StackGattServer.h BLE_StackHostMain.h BLE_StackL2cap.h Buzzer.h Buzzer_aliases.h BuzzerPWM.h cmsis_armcc.h cmsis_compiler.h cmsis_gcc.h core_cm0.h core_cm0_psoc4.h core_cmFunc.h core_cmInstr.h cy_em_eeprom.h cydevice_trm.h cydevicegnu_trm.inc cydeviceiar_trm.inc cydevicerv_trm.inc cydisabledsheets.h cyfitter.h cyfitter_cfg.h cyfittergnu.inc cyfitteriar.inc cyfitterrv.inc CyFlash.h CyLFClk.h CyLib.h cypins.h cyPm.h cytypes.h GreenLED.h GreenLED_aliases.h OutBeforeDown.h OutBeforeDown_aliases.h project.h PWM_CLK.h RedLED.h RedLED_aliases.h SCB_1.h SCB_1_BOOT.h SCB_1_PINS.h SCB_1_PVT.h SCB_1_rx.h SCB_1_rx_aliases.h SCB_1_SCBCLK.h SCB_1_SPI_UART.h SCB_1_SPI_UART_PVT.h SCB_1_tx.h SCB_1_tx_aliases.h UpBeforeIn.h UpBeforeIn_aliases.h WinchDownPin.h WinchDownPin_aliases.h WinchInPin.h WinchInPin_aliases.h WinchOutPin.h WinchOutPin_aliases.h WinchUpPin.h WinchUpPin_aliases.h YellowLED.h YellowLED_aliases.h
  group BLE_Imp/Generated_Source
    Generated_Source/PSoC4/: BLE.c BLE_bless_isr.c BLE_custom.c BLE_eventHandler.c BLE_gatt.c BLE_HAL_INT.c BLE_HAL_PVT.c Buzzer.c Buzzer_PM.c BuzzerPWM.c BuzzerPWM_PM.c Cm0Start.c cy_em_eeprom.c CyBootAsmIar.s cyfitter_cfg.c CyFlash.c CyLFClk.c CyLib.c cymetadata.c cyPm.c cyutils.c GreenLED.c GreenLED_PM.c OutBeforeDown.c OutBeforeDown_PM.c PWM_CLK.c RedLED.c RedLED_PM.c SCB_1.c SCB_1_BOOT.c SCB_1_PM.c SCB_1_rx.c SCB_1_rx_PM.c SCB_1_SCBCLK.c SCB_1_SPI_UART.c SCB_1_SPI_UART_INT.c SCB_1_tx.c SCB_1_tx_PM.c SCB_1_UART.c SCB_1_UART_BOOT.c UpBeforeIn.c UpBeforeIn_PM.c WinchDownPin.c WinchDownPin_PM.c WinchInPin.c WinchInPin_PM.c WinchOutPin.c WinchOutPin_PM.c WinchUpPin.c WinchUpPin_PM.c YellowLED.c YellowLED_PM.c
  group BLE_Imp/Header
    ./: BLE_Applications.h BuzzerImp.h common.h cyapicallbacks.h GPIO.h iprintf.h LEDs.h main.h
  group BLE_Imp/Source
    ./: BLE_Applocations.c BuzzerImp.c common.c GPIO.c iprintf.c LEDs.c main.c Tmaplets.c
